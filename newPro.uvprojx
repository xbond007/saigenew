# Keil uVision project newPro.uvprojx, settings and files
target CW32F003 (5060960::V5.06 update 7 (build 960)::.\Ac5)
  device: CW32F003F4 WHXY
  pack: WHXY.CW32F003_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00C00) IROM(0x00000000,0x05000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: newPro
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Libraries\inc;.\user
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group User
    ./: main.c
    ./user/: common.c timer.c
  group Core
    ./core/: cw32f003.h interrupts_cw32f003.c interrupts_cw32f003.h startup_cw32f003.s
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Peripheral
    ./Libraries/src/: cw32f003_adc.c cw32f003_atim.c cw32f003_awt.c cw32f003_btim.c cw32f003_crc.c cw32f003_debug.c cw32f003_digitalsign.c cw32f003_flash.c cw32f003_gpio.c cw32f003_gtim.c cw32f003_i2c.c cw32f003_iwdt.c cw32f003_lvd.c cw32f003_pwr.c cw32f003_ram.c cw32f003_rcc.c cw32f003_spi.c cw32f003_systick.c cw32f003_uart.c cw32f003_vc.c cw32f003_wwdt.c system_cw32f003.c
software components: CMSIS:CORE 5.6.0
